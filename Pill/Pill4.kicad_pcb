# Repository aeremin/chibi-armlet

File README.md:

Fallout Device project.

-- Moved from https://code.google.com/p/chibi-armlet

## KiCad design Pill/Pill4.kicad_pcb

Schematic: Pill4.sch

Parts:
C1: 0.1u; CAP_0603
DD1: M24C04; SO8E
F1, F2, F3: FUSE0R
XL1: CONN_4

Connections:
+3.3V: C1.1, DD1.8 (Vcc), F1.2, F2.2, F3.2, XL1.1
/1: DD1.1 (A0), F1.1
/2: DD1.2 (A1), F2.1
/3: DD1.3 (A2), F3.1
/I2C_SCL: DD1.6 (SCL), XL1.2 (PM)
/I2C_SDA: DD1.5 (SDA), XL1.4
GND: C1.2, DD1.4 (GND), DD1.7 (WP), XL1.3

Notes on the sheet:
I2C Addr = 1010 (A2)(A1)(A0) in case of 1 or 2 kBit, I2C Addr = 1010 (A2)(A1) in case of 4 kBit. A2, A1, A0 are read as 0 when left floating

Board: 2 copper layers, 24.6 x 10.4 mm, 6 parts (1 on the bottom side), 7 nets.

## KiCad design Hardware/ChibiArmlet.kicad_pcb

Parts:
ANT1: ANT_PCB_MONO
B3: BAT
BLN1: 0896BM15A0001
BZ1: BUZZER
C1, C12, C17: 10u; CAP_0603
C2: 1.8pF
C3, C8: 220pF
C4, C6: 10n
C5: 3.3pF
C7, C11, C21, C23: 0.1u
C9, C10: 10pF; CAP_0402
C13, C14, C18: 0.1u; CAP_0402
C15: 10n; CAP_0402
C16: 1u; CAP_0402
C22, C24: 10u
D1, D2: BAT54WS
DA1: NCP1400
DD1: STM32L151CXTX
DD2: CC1101
L1: 5.6nH; IND_0402
L2: 22uH
M1: MOTOR_PAD
Q1, Q2: MMBT2222
Q3: LED_RGB 5050
R1: 1k; RES_0402
R2: 56k
R4, R12: 1k
R5, R6: 4K7; RES_0402
R7: 150; RES_0402
R8, R9, R10: 51R; RES_0603
RP1, RP2: REFPOINT
TP1, TP2: TESTPOINT
XL1: ST_SWD
XL2: CONN_3
XL3: CONN_4
XL4: CONN_4
XTAL1: 27MHz; 03225

Connections:
+3.3V: BZ1.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C23.1, C24.1, D2.C, DA1.1 (CE), DA1.2 (OUT), DD1.1, DD1.9, DD1.24, DD1.36, DD1.48, DD2.4 (DVDD), DD2.9 (AVDD), DD2.11 (AVDD), DD2.14 (AVDD), DD2.15 (AVDD), DD2.18 (DGUARD), XL1.1 (Vdd)
+BATT: B3.A, C1.1, C21.1, C22.1, D1.C, L2.2, M1.2 (-), R1.2
/BLUE_LED: DD1.18, R10.1
/Buzzer: DD1.39, R4.1
/BuzzerOut: BZ1.2, Q2.3 (C)
/CC_CS: DD1.14, DD2.7 (CSn)
/CC_GDO0: DD1.13, DD2.6 (GDO0), TP1.1
/CC_GDO2: DD1.12, DD2.3 (GDO2), TP2.1
/CC_MISO: DD1.16, DD2.2 (SO(GDO1))
/CC_MOSI: DD1.17, DD2.20 (SI)
/CC_SCK: DD1.15, DD2.1 (SCLK)
/GREEN_LED: DD1.41, R9.1
/Lout: D2.A, DA1.5 (LX), L2.1
/P_SCL: DD1.45, R5.1, XL4.2 (PM)
/P_SDA: DD1.46, R6.1, XL4.4
/PeriphPwr: DD1.43, R5.2, R6.2, R7.2
/PeriphPwr1: R7.1, XL4.1
/RED_LED: DD1.19, R8.1
/RF1: BLN1.4 (Bal2), DD2.12 (RF_P)
/RF2: BLN1.3 (Bal1), DD2.13 (RF_N)
/SWCLK: DD1.37, XL1.2 (SWCLK)
/SWDIO: DD1.34, XL1.4 (SWDIO)
/UART_RX: DD1.31, XL2.3
/UART_TX: DD1.30, XL2.2 (PM)
/Vibro: DD1.42, R12.1
/VibroOut: D1.A, M1.1 (+), Q1.3 (C)
GND: B3.C, BLN1.2 (GND), BLN1.5 (GND), BLN1.6 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C21.2, C22.2, C23.2, C24.2, DA1.4 (GND), DD1.8, DD1.23, DD1.35, DD1.44, DD1.47, DD2.16 (GND), DD2.19 (GND), DD2.PAD (GND), M1.PAD (GND), Q1.2 (E), Q2.2 (E), Q3.BC (B), Q3.GC (G), Q3.RC, R2.2, XL1.3 (GND), XL2.1, XL3.4, XL4.3, XTAL1.H
unnamed: BLN1.1 (Unbal), L1.2
unnamed: Q3.BA, R10.2
unnamed: Q3.RA, R8.2
unnamed: Q3.GA, R9.2
unnamed: Q2.1 (B), R4.2
unnamed: C11.1, DD2.5 (DCOUPL)
unnamed: C10.1, DD2.10 (XOSC_Q2), XTAL1.2
unnamed: C9.1, DD2.8 (XOSC_Q1), XTAL1.1
unnamed: DD2.17 (RBIAS), R2.1
unnamed: DD1.10, R1.1
unnamed: ANT1.1, C2.1, L1.1
unnamed: Q1.1 (B), R12.2
unnamed: DD1.4, XL3.1
unnamed: DD1.3, XL3.2 (PM)
unnamed: DD1.2, XL3.3

Notes on the sheet:
Debug port
Programming
CPU
Indication
Power
Radio
Matching circuit
L-07C5N6SV4
500R07S1R8BV4
Peripheral I2C Pull-Ups
Pill Connector
Pill
1xAA
Just Pins

Board: 2 copper layers, 114.0 x 16.0 mm, 56 parts (0 on the bottom side), 42 nets.

File Hardware/Gerber/Berelcom/ChibiArmlet-BOM.xlsx:

Document version | ChibiArmlet-BOM v.20131229.1300
Reference | Footprint | Value | Item count | Price | URL | Комментарий
Микросхемы
DD1 | LQFP-48 | STM32L151CBT | 1 | $2.62 | http://www.compel.ru/infosheet/ST/STM32L151CBT6/
DD2 | QFN20 | CC1101 | 1 | $1.86 | http://www.compel.ru/infosheet/TI/CC1101RTKR/
DA1 | SOT23-5 | NCP1400ASN33 | 1 | $0.4044 | http://www.compel.ru/infosheet/ONS/NCP1400ASN33T1G/ | Источник питания
Активные компоненты
Q1, Q2 | SOT23 | MMBT2222 | 2 | $0.0101 | http://www.compel.ru/infosheet/NXP/MMBT2222A.215/
Q3 | LED5050 | LED_RGB | 1 | 1.86р | http://www.zip-2002.ru/?z=grey&i=119&p=651&id=96169/
D1, D2 | SOD-323 | BAT54WS | 2 | $0.023 | http://www.berelcom.ru/shop/show_good.php?idtov=2130747219&grid= | Диод Шоттки
Пассивные компоненты
XTAL1 | SMD3225 | 27MHz | 1 | 7.65р | http://www.quartz1.com/price/model.php?akt=6935.12 | Резонатор на 27МГц 10ppm в SMD корпусе размером 3.2х2.5мм
BZ1 | DIP2 | HC0903A | 1 | 7.5р | http://www.quartz1.com/price/model.php?akt=8420.12 | Пищалка
Конденсаторы
C1, C12, C17, C22, C24 | CAP_0603 | 10u 6.3V | 5 | $0.084 | http://www.compel.ru/infosheet/MUR/GRM188R60J106ME47D/ | Конденсатор в корпусе 0603, точность 20%, напряжение не менее 6.3В
C2 | CAP_0402 | 1.8pF | 1 | $0.045 | http://www.digikey.com/product-detail/en/500R07S1R8BV4T/712-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 | Конденсатор JOHANSON p/n 500R07S1R8BV4T
C3, C8 | CAP_0402 | 220pF | 2 |  |  | Конденсатор в корпусе 0402, диэлектрик NPO, точность 5%
C4, C6, C15 | CAP_0402 | 10n | 3 |  |  | Конденсатор в корпусе 0402, точность 20%
C5 | CAP_0402 | 3.3pF | 1 |  |  | Конденсатор в корпусе 0402, диэлектрик NPO, точность 5%
C7, C11, C13, C14, C18, C21, C23 | CAP_0402 | 0.1u | 7 |  |  | Конденсатор в корпусе 0402, точность 20%
C9, C10 | CAP_0402 | 10pF | 2 |  |  | Конденсатор в корпусе 0402, диэлектрик NPO, точность 5%
С16 | CAP_0402 | 1u | 1 |  |  | Конденсатор в корпусе 0402, точность 20%
Резисторы
R1, R4, R12 | RES_0402 | 1k | 3 |  |  | Резистор в корпусе 0402, точность не хуже 5%
R2 | RES_0402 | 56k | 1 |  |  | Резистор в корпусе 0402, точность не хуже 1%
R5, R6 | RES_0402 | 4k7 | 2 |  |  | Резистор в корпусе 0402, точность не хуже 5%
R7 | RES_0402 | 150R | 1 |  |  | Резистор в корпусе 0402, точность не хуже 5%
R8, R9, R10 | RES_0402 | 51R | 3 |  |  | Резистор в корпусе 0402, точность не хуже 5%
Индуктивности
L1 | IND_0402 | 5.6nH | 1 | $0.02926 | http://www.digikey.com/product-detail/en/L-07C5N6SV6T/712-14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 | Катушка JOHANSON p/n L-07C5N6SV6T
L2 | IND_1210 | 22uH | 1 | $0.14576 | http://www.digikey.com/product-detail/en/CBC3225T220MR/587-1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 | Индуктивность 22uH +- 20%, ток рабочий и насыщения не менее 500мА, сопротивлени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
BLN1 | BLN_0805 | 0896BM15A0001E | 1 | $0.5225 | http://www.compel.ru/infosheet/JOHANSON/0896BM15A0001E/
Разъемы
XL1, XL2, XL3 |  | Do not mount | 0
XL4 | DIP4 | PBS-1x04R | 1 | 1.29р | http://www.zip-2002.ru/?z=grey&i=97&p=332&id=58364/ | Разъем 1х4 угловой, шаг 2.54мм
B3 | Держатель 1хAA | BH311 | 1 | 4.11р | http://www.zip-2002.ru/?z=grey&i=109&p=401&id=59649/ | Держатель одной батарейки АА с монтажом на плату.
M1 |  | Do not mount | 0

## Code that names these connections

File Firmware/FalloutTx/inc/cc_gpio.h:

/*
 * cc_gpio.h
 *
 *  Created on: Nov 28, 2013
 *      Author: kreyl
 */

#ifndef CC_GPIO_H_
#define CC_GPIO_H_

// Pins
#define CC_GPIO     GPIOA
#define CC_GDO2     3
#define CC_GDO0     4
#define CC_SCK      5
#define CC_MISO     6
#define CC_MOSI     7
#define CC_CS       2

#if CC_GDO0 == 0
#define GDO0_IRQ_HANLER     EXTI0_IRQHandler
#elif CC_GDO0 == 1
#define GDO0_IRQ_HANLER     EXTI1_IRQHandler
#elif CC_GDO0 == 2
#define GDO0_IRQ_HANLER     EXTI2_IRQHandler
#elif CC_GDO0 == 3
#define GDO0_IRQ_HANLER     EXTI3_IRQHandler
#elif CC_GDO0 == 4
#define GDO0_IRQ_HANLER     EXTI4_IRQHandler
#endif

// SPI
#define CC_SPI      SPI1

#endif /* CC_GPIO_H_ */

## Commit log (part)

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2013-12-03 * Damage calculated in rlvl1. Calculations clarified.
2013-12-04 Detector added
2013-12-04 + Random clicking added.
2013-12-04 Detector reacts on emanator
2013-12-04 + Variative damage at FalloutTX and Detector works ok
2013-12-05 Emanators.svg added
2013-12-05 * Damage calculations and emanator iterations moved to h file
2013-12-05 Device code merged, seems to work.
2013-12-06 - Buttons - LCD - Quartz 32768
2013-12-09 + 4-pin connector for functionality raising
2013-12-10 Hardware v3, sent to pilot production
2013-12-28 + Vibro and sequences TODO: change sch & PCB to power vibro directly from battery.
2014-02-16 + Accelerations are read.
2014-03-13 Some unknown changes
2014-03-20 + mesh files; implemented mesh rx in radio thread; added EVT_MSK relative mesh; kl_lib: added function to timer; chconf: uses MAILBOXES; added new struct of Pkt.
2014-03-20 + MsgBox; fixed uninitialized RadioThread;
2014-03-21 + SensorTable.h; Move change Led color from main thd to App Thd; was defined Mesh Tim parametres (IRQ channel and e.t.c); added evt masks; kl_lib: min/max macros added; cleared some unused code.
2014-03-21 Rewrite how send event is executed.
2014-03-24 + real time unit used; create command to set time.
2014-03-24 + Doesn't work correctly with time synchronization by mesh.
2014-03-24 Fixed date put in RTC register. But should do it carefully.
2014-03-30 hw added
2014-03-31 Pill2 added
2014-03-31 Pill request added
2014-03-31 + gitignore
2014-04-01 + ID and Type setup added
2014-04-01 * EE write fixed (ee unlock added)
2014-04-02 * CC low level replaced with one from armlet, and successfully checked * Type setup modified * rpkt changed
2014-04-02 + SensorTable added
2014-04-02 + Terminal macroses
2014-04-03 * PKT_LEN now saved inside cc1101_t class
2014-04-04 + Excel with calculations + Special class for calculations
2014-04-04 Pill2 renamed to Pill3
2014-04-08 Done FwRTU. Next step is to make Mesh more clean.
2014-04-08 + Exclude RSSI from Pkt structure; Deleted Color from Mesh, rewrite dispatch mesh pkt.
2014-04-09 + gitignore, Excel Summing
2014-04-09 Pill3 for Beriozka prepared
2014-04-10 + Pill4 * Indication added
2014-04-11 + linker for stm32l151C8...; start to rewrite sensor table.
2014-04-11 + Led blink
2014-04-11 proceeding
2014-04-12 + Pill4.zip
2014-04-15 (-) Sensor Table; (+) Payload; Mesh_Params; Start to decrease filled RAM.
2014-04-15 Removed Message box; Added Payload to radio packet, increased SLOT_TIME due to packet time transmit, IMPORTANT! Rewrite CC1101 pkt length.
2014-04-15 + Update Mesh current cycle number by uart console.
2014-04-15 Start to sync devices by mesh parameters.
2014-04-15 distance Constants defined
2014-04-16 * Lite changes in UART cmd exec
2014-04-16 + Demonstrate type with color
2014-04-16 + Device type setup with pill
2014-04-16 * Vibro sequences
2014-04-18 + 500kBps radio bitrate added
2014-04-21 * RxTable now has no initiative
2014-04-22 + Payload information send to console; Filled radio packet with data moved to mesh; Create Time age Keeper function. Need to do: Remove SelfInfo and keep info about ourselves in 700-size buffer.
2014-04-22 Rx/Tx test
2014-04-22 Detector beeps and lights. Field does not react on detector, though.
2014-04-23 + Detector seems ok + ADC work started
2014-04-30 + Changed print info logic.
2014-04-30 + Answer to console command SET_NEW_CYCLE.
2014-05-03 * Move to event-driving concept + Set ID by Pill implemented - Shiko traces removal in progress
2014-05-03 Testing firmware completed. + Radio Enabled only after first pill connection + During pill connection, Radio disabled.
2014-05-03 renamed
2014-05-03 Restore of old functionality in progress. + SetConsts cmd (still not saved in EE) + Read consts from EE
2014-05-03 + Pill SetConsts implemented + Uart GetConsts implemented
2014-05-03 + UART Get/Set dose implemented
2014-05-04 * CmdUart thread removed, polling implemented using main thread
2014-05-04 * Now only one constant is setup: DoseTop. Others calculated out of it.
2014-05-04 + RxTable; Table received successfully, fixed bug with PutData + Lustra implemented. Debug mode only, all parameters hard-coded.
2014-05-05 New cycle counter logic changed.
2014-05-05 Compiled successfully.
2014-05-06 + Add payload; Need to fix time counter.
2014-05-06 Mesh and payload reception/broadcast seems to work correctly.
2014-05-06 Remove debug print and ready to integrate with console.
2014-05-06 + PillProg
2014-05-06 + Cmd get mesh info.
2014-05-07 Uart Cmd switch to text-based protocol
2014-05-08 Text protocol in progress
2014-05-08 + Conversion of token inside Cmd_t + CmdUnknown ErrorCode + Hexadecimal and decimal conversion
2014-05-08 PillProg ready
2014-05-08 UMVOS'commands reimplemented
2014-05-13 * All data in pill int32 * Structure of Pill - Infinity + new types of pill + PillProg prints pill when inserted
2014-05-13 * TermMacro
2014-05-15 * Convert string to (u)int32 modified to return NaN or EmptyString
2014-05-15 PillProg release candidate
2014-05-15 + RepeatWrite32: if pill is already connected, write it immediately
2014-05-15 Device types switched to enum
2014-05-21 Resolve conflicts.
2014-05-21 Switch to interactive dev type in progress * Fixed Damage=0 detector bug
2014-05-22 * Lustra pkts are now array
2014-05-22 in progress
2014-05-22 - Removed compare timestamp before write data to payload buff.
2014-05-22 + Fixed SelfID change in mesh pkt if new ID is setting by the Uart.
2014-05-23 + OnPillDisconnect
2014-05-23 + RxTable Age added
2014-05-23 * Timings adjusted experimentally
2014-05-24 + Pelengator functionality implemented and slightly tested + OnBlinkEnd functionality added to LED
2014-05-24 * Peleng RSSI comparision moved from application to RadioLevel1
2014-05-25 + Pill Cure/Damage + Tested Pill SetTop + Panacea
2014-05-25 * DoseAfter always written to pill
2014-05-27 + Posted RSSI to Mesh Thread.
2014-05-27 Implement stationary device listening.
2014-05-27 Ready update Location data.
2014-05-27 Random seed is a SelfID of the device.
2014-05-27 All removed save radio
2014-05-27 Need to fix bug with RxCycle counter.
2014-05-27 * chSysUnlock added where it needed
2014-05-28 + Fix CurrCycle Counter, radio level thread now is normal priority due to BucketHandler couldn't correct fetch msg from msgbox.
2014-05-28 Need to fix bug with incorrect timediff.
2014-05-28 Look Up a "chSchReadyI() #1 @MeshLvl" error. StackOverflow sometimes!!!
2014-05-28 Timestamp compare.
2014-05-28 First working version of indication (just a beginning, though)
2014-05-29 + define start cycle for mesh, fixed payload function WriteInfo and getnextinfoID;
2014-05-29 + Timeage copy during synchronization is done when get privilege time from privilege ID.
2014-05-29 Indication changed, pill indication based on event.
2014-05-30 * PwmPin bug found and fixed
2014-05-30 + Pelengator implemented + Type Change now event-driven
2014-05-31 Autodoc in progress
2014-06-01 + Autodoc completed and tested + Indication ok + Autodoc indication added and tested
2014-06-02 + Fixed detector implemented
2014-06-02 Fixed bug with big TimeDiff.
2014-06-03 Fixed strange number in pkt In process.
2014-06-03 Time age new bug appeared. Now fixed. (Do not update TimeOwner ID when receive more privilege time).
2014-06-04 Send data in console in N times.
2014-06-04 Proceeding with grenade. Todo: pill, radio, testing.
2014-06-05 * Autodoc changed, not tested + Grenade charging
2014-06-05 + Grenade's radio
2014-06-05 + EmpState saved after radio break
2014-06-05 * macros
2014-06-07 + Lustra bad ID, not tested
2014-06-07 Pelengator reception made 4Tx-1RX.
2014-06-07 DetectorMobile tested
2014-06-09 StackOvf @rLvl1.
2014-06-09 StackOvf @rLvlThd agreed.
2014-06-17 StageCommit
2014-06-17 * EE.Write32: write if not the same. Same check removed everywhere else.
2014-06-17 - Async RX/TX removed - CC.State removed as not required
2014-06-17 Great changes. + split to pkt_time and guard_time; + (important) fixed *PTimeToWakeUp function count; + CorrctionTimeStamp func; + rewrite RxCycle logic in RadioThd; + small changes.
2014-06-20 * Lustra Count increased to 50
2014-06-20 * Lustra Max ID repaired
2014-06-20 Flash.bat edited
2014-06-23 + Fixed payload timestamp update.
2014-07-06 Gyro works
2014-07-07 Acc and compass work
2014-07-09 + RxTable.
2014-07-14 + Console print info.
2014-07-15 GetAstronomicTime done.
2014-07-17 + clear buf and verify step over 23:59 to 00:00
2014-08-23 + Acc & Gyro
2014-08-28 Common Mesh with Armlet.
2014-08-29 Increase uart buffer.
2014-08-30 добавил AtlSharedLogic вфайл проекта, в нем лежат emotions c,h часть логикитумана
2014-08-30 * RxTable returns!
2014-08-30 * proceeding: emotion=0
2014-08-30 правка локаций, игротехник страха на люстре включен
2014-08-30 FollowUp
2014-09-01 New ID setup printf corrected.
2014-09-03 Uart buffer size now 128 bytes.
2014-09-03 Move project to common location.
2014-09-04 Proceeding with RGB LED
2014-09-05 New Evt mask.
2014-09-05 Proceeding with LED
2014-09-06 LED switch constant calculated using time
2014-09-06 группа мастерских люстр теперь вырубает на всех других люстрах включенный туман
2014-09-06 вкл выкл синий, туман всё еще тестовый!!!!
2014-09-07 - debug in RGB
2014-09-07 уарт отладка тумана включена
2014-09-07 зеленый свет ок, убрана выдача на люстре в уарт
2014-09-07 * CheckIfGreen: treshold & timeout adjusted
2014-09-07 + Battery measurement
2014-09-07 Release Candidate 20140908 0120
2014-09-10 Mesh Sniffer
2014-10-16 Add battery to mesh packet. Updates in cc1101.* files to transmit faster.
2014-10-16 New CC1101 tx logic.
2014-10-23 Release candidate v.1
2014-10-23 * Fixed bug in detector disallowing it to detect lethal lustras.
2014-10-23 Release candidate v.2
2014-12-21 * CmdUart transmission made same as in armlet
2015-03-28 Migrating wiki contents from Google Code
2015-05-30 Switch to newer libs
2015-05-31 + Async protocol seems implemented
2015-05-31 Indication done Release candidate
2015-06-07 Release version * switched to 500kBit/s * Power lowered to -10dBm
2015-06-23 Radio RX, still 250kBit
2015-06-25 + MSI range setup + WS LED switches color correctly But sequensor still not implemented
2015-06-25 + WS2812 sequensor implemented + Switch delay moved to Color_t
2015-06-25 + "Indication off" delay implemented
2015-06-25 * RX timing lowered
2015-08-05 Move of files. Removed Basic, Tx, etc.
2015-08-05 Refactored code compiled successfully
2015-08-05 switching from periph
2015-08-08 * EEStore rewritten and tested This is test assembly
2015-08-08 - ee debug * all game mech returned
2015-08-08 + Version + EEPROM erase during autoflash
2015-08-08 * Radio constants
2015-12-11 Minor removals
2015-12-11 Minor changes. Release
2016-07-23 Set received color
2016-11-09 First
2017-06-10 * React depending on MinPwrToReact field in Pkt
2017-12-21 Minor color changes
2018-05-12 Some sch changes
2018-05-12 + New os and folder struct
2018-05-12 + Influence read/ write + Some radio
2018-05-12 Minor cleaning
2018-05-20 + Led on if RSSI is high enough
2018-05-25 Backlink to CADLAB.io has been added.
2018-06-19 Maybe RC
2018-07-15 Different modes implemented.
2018-07-17 Alpha
2018-07-31 Compiled successfully
2018-08-03 RF Pwr & sensitivity increased
2018-11-29 Steady blue
2019-04-14 Switch to newer OS etc.
2019-04-15 * Channel space
2019-05-04 + Control of power and damage etc.
2019-05-04 + Blink and Beep on demand * Switch to TIM9 as sys timer
2019-05-05 + Seems working
2019-05-05 * 5 times per second
2019-05-06 Every 198ms
2019-05-09 Sync versions with Locket.
2019-05-09 Switch to same averaging algorythm as for player
2019-06-25 Minor
2019-06-26 Green or White
2019-06-30 + SetID.bat
2019-06-30 + Radio RX
2019-06-30 + Integration with SM works
2019-07-01 dispatch fixed, pill idle timer tick added
2019-07-02 1m flashes fixed, medium beep added, dispatch of heal added
2019-07-03 GHOUL_PILL_REMOVED logic added, test_pill sent to player sm
2019-07-03 indication timeouts decreased, brightness decreased
2019-07-05 Radiostructure updated
2019-07-15 last updates
2019-08-14 Proceeding with Mesh
2019-08-14 + TransmitterID ProcessCmd done
2019-08-19 Lots of changes
2019-08-20 + Power in Beacon
2019-08-22 Timings changed to sleep more. Mesh retransmitted non-stop for 324ms
2019-09-19 Adjust board.h to be able to run on Locket
